# Keil uVision project FlyThingsLite_X1.uvprojx, settings and files
target FlyThingsLite_X1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32G030C8Tx STMicroelectronics
  pack: Keil.STM32G0xx_DFP.1.2.0
  cpu: IRAM(0x20000000,0x00002000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: FlyThingsLite_X1 +hex
  AfterMake: fromelf.exe --bin -o @L.bin "!L"
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32G030xx
  c include: ../Core/Inc;../Drivers/STM32G0xx_HAL_Driver/Inc;../Drivers/STM32G0xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32G0xx/Include;../Drivers/CMSIS/Include;../include;../user;../flyport;../uifun;../flyport/bsp;../uilogic;../function
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  scatter file: FlyThingsLite_X1\FlyThingsLite_X1.sct
  group Application/MDK-ARM
    ./: startup_stm32g030xx.s
  group Application/User/Core
    ../Core/Src/: main.c stm32g0xx_it.c stm32g0xx_hal_msp.c
  group Drivers/STM32G0xx_HAL_Driver
    ../Drivers/STM32G0xx_HAL_Driver/Src/: stm32g0xx_hal_i2c.c stm32g0xx_hal_i2c_ex.c stm32g0xx_hal_rcc.c stm32g0xx_hal_rcc_ex.c stm32g0xx_ll_rcc.c stm32g0xx_hal_flash.c stm32g0xx_hal_flash_ex.c stm32g0xx_hal_gpio.c stm32g0xx_hal_dma.c stm32g0xx_hal_dma_ex.c stm32g0xx_ll_dma.c stm32g0xx_hal_pwr.c stm32g0xx_hal_pwr_ex.c stm32g0xx_hal_cortex.c stm32g0xx_hal.c stm32g0xx_hal_exti.c stm32g0xx_hal_spi.c stm32g0xx_hal_spi_ex.c stm32g0xx_hal_tim.c stm32g0xx_hal_tim_ex.c stm32g0xx_hal_uart.c stm32g0xx_hal_uart_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32g0xx.c
  group bsp
    ../flyport/bsp/: dev_time17.c dev_pwm.c
  group widget_Inc
    ../include/widget/: animation.h button.h image.h imagetext.h increment.h label.h numtext.h progress.h qrcode.h widget.h window.h
  group flythings
    ../flythings/: flythings_symbol.txt
  group flyport
    ../flyport/event/: SDL_event.c
    ../flyport/graphics/: video.c
    ../flyport/timer/: SDL_timer.c
    ../flyport/: SerialFlash.c
    ../flyport/ext_flythings/: switch_image.c draw_point.c
  group user
    ../user/: devmodule.c ring.c other_app.c usermain.c uartupgradedev.c proc_cmd.c flash_save.c inputkey.c
  group function
    ../function/: delay.c IM_Controls.c dev_chsc6540.c.c
  group uifun
    ../uifun/: ui_context.c ui_page.h ui_res_image.h
    ../uifun/logic/: air.c coffe.c coffework.c cook.c cookwork.c menu.c oil.c rice.c ricework.c wash.c wash2.c washwork.c test.c test2.c
software components: CMSIS:CORE 5.1.2
